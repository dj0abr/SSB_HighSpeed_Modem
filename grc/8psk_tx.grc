options:
  parameters:
    author: kurt
    comment: |-
      requires GNU Radio 3.8xxx
      does NOT work with 3.7x
    description: requires GNU Radio 3.8xxx
    gen_cmake: 'Off'
    generate_options: no_gui
    id: tx_8psk
    output_language: python
    run_options: run
    title: 8PSK Modem  DJ0ABR
  states: {}

blocks:
- name: mixf
  id: variable
  parameters:
    comment: |-
      mid frequency
      in the audio
      spectrum. Set to get
      lowest and highest
      frequency within the
      transceiver filter range.
    value: '1500'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Samples/Symbol
      fixed value,
      do not change.
      Used to adjust
      bitrate vs. bandwidth
    value: '1'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      the modulator output is in the baseband at 0 Hz.
      Mix it with the required audio mid frequency.
      cos and -sin are used to combine I and Q
      into the final signal.
    freq: mixf
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: |-
      send audio to
      transceiver
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: |-
      generate the analog
      output signal.
    type: float
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      reduce level for the
      audio output, improves
      linearity
    const: '0.05'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      mix I und Q 
      to the mid 
      frequency
      specified in
      "mixf"
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: |-
      receive an UDP data stream
      with the bitrate of (see 
      comment samp_rate)
      The stream is buffered, 
      so send some bytes ahead
      to prefill the buffer
      and avoid underrun
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40134'
    psize: '258'
    type: byte
    vlen: '1'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      This modulator expects "Packed Bytes"
      which are 8 bits within one byte.
      The UDP source block deliveres bytes,
      so it fits perfectly.
    constellation: digital.constellation_8psk_natural().base()
    differential: 'True'
    excess_bw: '0.25'
    samples_per_symbol: resamprate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: resamprate
  id: parameter
  parameters:
    label: resamprate
    short_id: r
    type: intx
    value: '24'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: Audio Rate
    label: samp_rate
    short_id: s
    type: intx
    value: '48000'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_1, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_1, '1', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_float_1, '0']
- [blocks_udp_source_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
