options:
  parameters:
    author: kurt
    comment: |-
      requires GNU Radio 3.8xxx
      does NOT work with 3.7x
    description: requires GNU Radio 3.8xxx
    gen_cmake: 'Off'
    generate_options: no_gui
    id: rx_8psk
    output_language: python
    run_options: run
    title: 8PSK Modem  DJ0ABR
  states: {}

blocks:
- name: mixf
  id: variable
  parameters:
    comment: |-
      mid frequency
      in the audio
      spectrum. Set to get
      lowest and highest
      frequency within the
      transceiver filter range.
    value: '1500'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: outputsps
  id: variable
  parameters:
    comment: |-
      Samples/Symbol
      fixed value,
      do not change.
      Used to adjust
      bitrate vs. bandwidth
    value: '7'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.1/float(sps), 0.2, 11*sps*nfilts)
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Samples/Symbol
      fixed value,
      do not change
    value: '4'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    comment: Costas loop needs AGC (loop gain depends on input level)
    decay_rate: '0.2'
    gain: '2'
    max_gain: '3'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      Marker to find the start
      of the values
    const: '1000'
    type: int
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    comment: |-
      Marker to find the start
      of the values
    const: '1000'
    type: int
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '16777216'
    type: float
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      the modulator output is in the baseband at 0 Hz.
      Mix it with the required audio mid frequency.
      cos and -sin are used to combine I and Q
      into the frinal signal.
      Use it als for RX in the reverse direction
    freq: mixf
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: get audio from transceiver
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      combile I and Q
      to complex signal
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '16777216'
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: '16777216'
  states: {}
- name: blocks_float_to_int_0_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: int
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    num_streams: '3'
    type: int
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    comment: make I
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    comment: make Q
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      send RX data to UDP
      port 1235 on the local machine
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40135'
    psize: '344'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      send QPSK Constellation data to UDP
      port 1236 on the local machine
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40136'
    psize: '120'
    type: int
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      send QPSK Constellation data to UDP
      port 1236 on the local machine
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40137'
    psize: '120'
    type: int
    vlen: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      8PSK decoding, same
      parameters as modulator
    constellation: digital.constellation_8psk_natural().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      locks the signal and
      converts into baseband
    order: '8'
    w: '0.15'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: digital.constellation_8psk_natural().base()
    mu: '0.01'
    num_taps: '15'
    sps: outputsps
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      synchronize the Clock,
      works very well with drifting
      QO-100 signal
    filter_size: nfilts
    init_phase: nfilts/16
    loop_bw: '0.06'
    max_dev: '2'
    osps: outputsps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Anti-Aliasing filter
      Level correction
      and decimation
    cutoff_freq: '3900'
    decim: '1'
    gain: '12'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3300'
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resamp
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate / 8000
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: resamp
  id: parameter
  parameters:
    comment: |-
      Resampling Rate
      from Audio Rate
      to 8kS/s which is
      the input of the 
      Polypashe Clock
    label: resamp
    short_id: r
    type: intx
    value: '6'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: Audio Rate
    label: samp_rate
    short_id: s
    type: intx
    value: '48000'
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [analog_const_source_x_0, '0', blocks_interleave_0, '0']
- [analog_const_source_x_0_0, '0', blocks_interleave_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_multiply_xx_0_1_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_complex_to_float_1, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', mmse_resampler_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_int_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_int_0_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0, '0', mmse_resampler_xx_0, '0']
- [blocks_float_to_int_0, '0', blocks_interleave_0_0, '1']
- [blocks_float_to_int_0_0, '0', blocks_interleave_0_0, '2']
- [blocks_float_to_int_0_1, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_interleave_0_0, '0', blocks_udp_sink_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0_1_0, '0', blocks_float_to_int_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_udp_sink_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', analog_agc2_xx_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_1, '0']
- [mmse_resampler_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_multiply_xx_0_1_0, '0']

metadata:
  file_format: 1
