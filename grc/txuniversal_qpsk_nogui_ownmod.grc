options:
  parameters:
    author: DJ0ABR
    comment: |-
      requires GNU Radio 3.8xxx
      does NOT work with 3.7x
    copyright: DJ0ABR
    description: requires GNU Radio 3.8xxx
    generate_options: no_gui
    id: qpsk_tx
    output_language: python
    run_options: run
    title: 'QPSK TX-Modem '
  states: {}

blocks:
- name: mixf
  id: variable
  parameters:
    comment: |-
      mid frequency
      in the audio
      spectrum. Set to get
      lowest and highest
      frequency within the
      transceiver filter range.
    value: '1500'
  states: {}
- name: qpsk__constellation
  id: variable_constellation_rect
  parameters:
    comment: |-
      alternative:
      [0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]
      does not make a difference
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      the modulator output is in the baseband at 0 Hz.
      Mix it with the required audio mid frequency.
      cos and -sin are used to combine I and Q
      into the final signal.
    freq: mixf
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: |-
      send audio to
      transceiver
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: |-
      generate the analog
      output signal: USB
      (for LSB use substraction)
    type: float
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      reduce level for the
      audio output, improves
      linearity
    const: '0.05'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      mix I und Q 
      to the mid 
      frequency
      specified in
      "mixf"
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: |-
      receive an UDP data stream
      with the bitrate of (see 
      comment samp_rate)
      The stream is buffered, 
      so send some bytes ahead
      to prefill the buffer
      and avoid underrun
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40134'
    psize: '258'
    type: byte
    vlen: '1'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      unpack bytes to bits
      make symbols 2bits/sym
      make constellation
    constellation: qpsk__constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: resamprate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: resamprate
  id: parameter
  parameters:
    label: resamprate
    short_id: r
    type: intx
    value: '20'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: Audio Rate
    label: samp_rate
    short_id: s
    type: intx
    value: '44100'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_1, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_1, '1', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_float_1, '0']
- [blocks_udp_source_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
